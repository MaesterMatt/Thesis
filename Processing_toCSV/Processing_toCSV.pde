/*
Saving Values from Arduino to a .csv File Using Processing – Pseduocode

This sketch provides a basic framework to read data from Arduino over the serial port and save it to .csv file on your computer.
The .csv file will be saved in the same folder as your Processing sketch.
This sketch takes advantage of Processing 2.0’s built-in Table class.
This sketch assumes that values read by Arduino are separated by commas, and each Arduino reading is separated by a newline character.
Each reading will have it’s own row and timestamp in the resulting csv file. This sketch will write a new file a set number of times. Each file will contain all records from the beginning of the sketch’s run.
This sketch pseduo-code only. Comments will direct you to places where you should customize the code.
This is a beginning level sketch.

The hardware:
* Sensors connected to Arduino input pins
* Arduino connected to computer via USB cord

The software:
*Arduino programmer
*Processing (download the Processing software here: https://www.processing.org/download/
*Download the Software Serial library from here: http://arduino.cc/en/Reference/softwareSerial

Created 12 November 2014
By Elaine Laguerta
http://url/of/online/tutorial.cc

*/

import processing.serial.*;
Serial myPort; //creates a software serial port on which you will listen to Arduino
Table dataTable; //table where we will read in and store values. You can name it something more creative!
int value = 0;
int numReadings = 1; //keeps track of how many readings you’d like to take before writing the file.
int readingCounter = 0; //counts each reading to compare to numReadings.

String fileName, val;
void setup()
{
  String portName = "/dev/ttyACM1";
  //CAUTION: your Arduino port number is probably different! Mine happened to be 1. Use a "handshake" sketch to figure out and test which port number your Arduino is talking on. A "handshake" establishes that Arduino and Processing are listening/talking on the same port.
  //Here’s a link to a basic handshake tutorial: https://processing.org/tutorials/overview/
  
  myPort = new Serial(this, portName, 9600); //set up your port to listen to the serial port
  dataTable = new Table();
  
  dataTable.addColumn("id"); //This column stores a unique identifier for each record. We will just count up from 0 – so your first reading will be ID 0, your second will be ID 1, etc.

  //the following are dummy columns for each data value. Add as many columns as you have data values. Customize the names as needed. Make sure they are in the same order as the order that Arduino is sending them!
  dataTable.addColumn("sensor1");
  dataTable.addColumn("sensor2");
  dataTable.addColumn("sensor3");

}

void serialEvent(Serial myPort){
  try {
    val = myPort.readStringUntil('\n'); //The newline separator separates each Arduino loop. We will parse the data by each newline separator.
    if (val!= null) { //We have a reading! Record it.
    val = trim(val); //gets rid of any whitespace or Unicode nonbreakable space
    println(val); //Optional, useful for debugging. If you see this, you know data is being sent. Delete if you like.
    int sensorVals[] = int(split(val, ',')); //parses the packet from Arduino and places the valeus into the sensorVals array. I am assuming floats. Change the data type to match the datatype coming from Arduino.
    
    TableRow newRow = dataTable.addRow(); //add a row for this new reading
    newRow.setInt("id", dataTable.lastRowIndex());//record a unique identifier (the row’s index)
   
    //record sensor information. Customize the names so they match your sensor column names.
    newRow.setInt("sensor1", sensorVals[0]);
    newRow.setInt("sensor2", sensorVals[1]);
    newRow.setInt("sensor3", sensorVals[2]);
    
    readingCounter++; //optional, use if you’d like to write your file every numReadings reading cycles
    
    //saves the table as a csv in the same folder as the sketch every numReadings.
    if (value == 255)//The % is a modulus, a math operator that signifies remainder after division. The if statement checks if readingCounter is a multiple of numReadings (the remainder of readingCounter/numReadings is 0)
      {
        value = 0;
        fileName = str(year()) + str(month()) + str(minute()) + str(dataTable.lastRowIndex()); //this filename is of the form year+month+day+readingCounter
        saveTable(dataTable, fileName, "csv"); //Woo! save it to your computer. It is ready for all your spreadsheet dreams.
        dataTable = new Table();
        dataTable.addColumn("id"); //This column stores a unique identifier for each record. We will just count up from 0 – so your first reading will be ID 0, your second will be ID 1, etc.

        //the following are dummy columns for each data value. Add as many columns as you have data values. Customize the names as needed. Make sure they are in the same order as the order that Arduino is sending them!
        dataTable.addColumn("sensor1");
        dataTable.addColumn("sensor2");
        dataTable.addColumn("sensor3");

      }
    }
  }
  catch(RuntimeException e) {
    e.printStackTrace();
  }
}

void draw()
{
  fill(value);
  rect(25,25,50,50);
//visualize your sensor data in real time here! In the future we hope to add some cool and useful graphic displays that can be tuned to different ranges of values.
}

void keyPressed(){
  if(value == 0){
    value = 255;
  }
  else{
    value = 0;
  }
}